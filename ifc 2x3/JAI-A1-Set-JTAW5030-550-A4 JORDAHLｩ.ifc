Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2019-12-06T11:06:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 06 11:06:24 2019 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{74A786C7-D020-4F49-AB54-1AE33FD45CAD}\ifc * Database version: 5507 * Database creation date: Fri Dec 06 11:06:23 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 06 11:06:24 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 06 11:06:24 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige - Kategorie: Ebenen; Familienname: Ebene; Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
ID-Daten - Typname: Ebene; Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Grafiken - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten - Basishöhe: Projekt-Basispunkt; Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m

# IfcFastener: JTA-W L=550 mm, JAI-set with JTA-W JORDAHL® AnchorChannels:JTA-W L=550 mm:381462
In: Ebene 0
Type - Material: Steel, Stahl, S 355, Elastomer
Type - Abhängigkeiten - length: 0.55 m; Vorgabe-Ansicht: 0 m
Type - Allgemein - Design country: Germany; Edition number: 1; Manufacturer country: Germany; Manufacturer name: JORDAHL; min_number_anchor: 2; Product family: Fastening; Product group: Anchor Channels; Product SKU: anchor-channels-jta-w; tk: 0.002 m; Weight Net (Kg): 0
Type - Daten - min_number_of_T_bolts: 2; T Bolt Min Length: 0.03 m
Type - ID-Daten - Beschreibung: Die warmgewalzten JORDAHL® Ankerschienen bilden zusammen mit den passenden JORDAHL® Hakenkopfschrauben sowie dem JORDAHL® Zubehör ein vielseitiges und bewährtes Befestigungssystem. Einbetoniert verankern sie hohe Lasten zuverlässig in bewehrte und unbewehrte Bauteile und nehmen Last aus Zug und Querzug senkrecht zur Schienenachse auf.; certification EC conformity: http://downloads.jordahl-group.com/files/certificates/EC-Certificate_of_Conformity_2013_JTA.pdf; Date: 11-09-2013; Hersteller: JORDAHL® GmbH; Installation instructions: http://downloads.jordahl-group.com/files/instructions/LIT-JTA-MA-DE.pdf; Modell: LOD300; Product certification: http://downloads.jordahl-group.com/files/approvals/ETA_09-0338__JORDAHL_Anchor_Channels_JTA.pdf; Product data url: https://bimobject.com/jordahl/product/anchor-channels-jta-w; Revision Date: 10-08-2017; Technical description: http://downloads.jordahl-group.com/files/brochures/LIT-SUZ-B-EN_Channels_and_Accessories_high.pdf; Typname: JTA-W L=550 mm; URL: http://www.jordahl-group.com/en/317/products/connection-systems/anchor-channels-jta-w/; Version: 2017.1
Type - Materialien und Oberflächen - Material main: Steel; Material secondary: Zink
Type - Sichtbarkeit - jusiterbar(proof): A1J-jusiterbar; nicht justierbar(proof): A1-nicht justierbar; proof 40-22: 40-22; proof 50-30: 50-30
Type - Sonstige - Kategorie: Anschluss; Familienname: JAI-set with JTA-W JORDAHL® AnchorChannels
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; channel profil: 50-30; Ebene: Ebene: Ebene 0; Erhebung: 0 m; JAI justierbar: A1-nicht justierbar; technical approval ETA-09/0338 - Anchor Channels JTA: http://downloads.jordahl-group.com/files/approvals/ETA-09_0338_en_2018-6-18.pdf; Warning Overconstraint: no; Website: http://www.jordahl-group.com/en/317/products/fastening-technology/anchor-channels-jta-w/
Abmessungen - Fläche: 0.187599 m2; Volumen: 0.00105311 m3
Allgemein - calculate_H: 0.068 m; calculate_max_spacing_anchor: 0.25 m; calculate_ØbA: 0.0045 m; calculate_ØD: 0.0135 m; calculate_Øk1: 0.0085 m; edge_distance_anchor: 0.025 m; H_SharedParameter: 0.09 m; number_anchor: 3; tD: 0.0025 m
Daten - b1: 0.017 m; b2: 0.0325 m; calculate_edge_distance_1.T_bolt: 0.075 m; calculated number of T Bolts: 2; hooked_head_T_bolt: no; hooked_head_T_bolt_pair: yes; k: 0.008 m; max_spacing_length: 0.5 m; Max Clamping Length: 0.092 m; min_spacing_length: 0.08 m
HLS - JAI_h_anschluss: 0.03 m; JAI_L_LL: 0.0008 m
ID-Daten - tender text: JORDAHL®Ankerschienen JTA-... / ...-CE oder gleichwertig zum Einbetonieren, feuerverzinkt (fv) / aus nichtrostendem Stahl 1.4571/1.4401/1.4404 (A4) mit Vollschaumfüllung, für statische (und nicht ruhende) Beanspruchungen Europäisch-Technische Zulassung (ETA-09/0338), Einzellänge ........ mm, für die justierbare Befestigung von Anschluss- konstruktionen, liefern und entsprechend der Einbauanleitung des Herstellers an der Schalung befestigen. Für die einfache Berechnung von Befestigungsproblemen hilft Ihnen die JORDAHL® Expert Software. Unsere ETA-09/0338 Zulassung; Youtube clip: http://www.jordahl-group.com/en/256/service/installation-videos/#
Konstruktion - JAI 1 edge distance: 0.075 m; Number of T Bolts: 2; T Bolt Diameter: 0.016 m; T Bolt length: 0.08 m; T Bolt spacing: 0.15 m; T Bolt type: JC M16; Thickness of Attaching part: 0.042 m
Materialien und Oberflächen - Material_Hot Dip Galvanized: no; material Stainless Steel: yes; Tragendes Material: Stahl, Edelstahl
Modelleigenschaften - b: 0.0395 m; d: 0.018 m; f1: 0.003 m; h: 0.022 m; t1: 0.0025 m
Phasen - Phase erstellt: Phase 1
Sonstige - Bauteillistenebene: Ebene: Ebene 0; Familie: JAI-set with JTA-W JORDAHL® AnchorChannels: JTA-W L=550 mm; Familie und Typ: JAI-set with JTA-W JORDAHL® AnchorChannels: JTA-W L=550 mm; nut height m: 0.0148 m; nut radius: 0.008 m; nut s: 0.024 m; Typ: JAI-set with JTA-W JORDAHL® AnchorChannels: JTA-W L=550 mm; Typ-ID: JAI-set with JTA-W JORDAHL® AnchorChannels: JTA-W L=550 mm; washer D: 0.03 m; washer t: 0.003 m
Text - delivery date: xx.xx.xxxx; Pos.: 1a
Tragwerk - Bewehrungsüberdeckung: Bewehrungsüberdeckung - Einstellungen: Bewehrungsüberdeckung 1
